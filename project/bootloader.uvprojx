# Keil uVision project bootloader.uvprojx, settings and files
target qitas (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: -O1 -g -W
  c include: ..\loader;..\loader\ed25519
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../loader/: common.c flash.c lowlevel.c main.c image.c blake2s.c memzero.c
  group ed25519
    ../loader/ed25519/: ed25519.c curve25519-donna-32bit.c curve25519-donna-helpers.c curve25519-donna-scalarmult-base.c ed25519-donna-32bit-tables.c ed25519-donna-basepoint-table.c ed25519-donna-impl-base.c modm-donna-32bit.c sha2.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StartupConfig 8.17.0
